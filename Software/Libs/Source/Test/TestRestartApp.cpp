#define LOG_MODULE_PRX      "TestRestartApp"
#define LOG_MODULE_LEVEL    LOG_LEVEL_DEBUG
#include "Logger.h"

#include "Test/TestRestartApp.hpp"
#include "Backend.hpp"
#include "SwTimer.hpp"

////////////////////////////////////////////////////////////////////////////////
//// Defines
////////////////////////////////////////////////////////////////////////////////

////////////////////////////////////////////////////////////////////////////////
//// Data types
////////////////////////////////////////////////////////////////////////////////

////////////////////////////////////////////////////////////////////////////////
//// Private data
////////////////////////////////////////////////////////////////////////////////

////////////////////////////////////////////////////////////////////////////////
//// Private code
////////////////////////////////////////////////////////////////////////////////

////////////////////////////////////////////////////////////////////////////////
//// Public code
////////////////////////////////////////////////////////////////////////////////

void TestRestartApp_execute()
{
    LOG_INFO("start\n");

    const uint32_t pid = 0x9B367238;

    LOG_DEBUG("appStart [pid = 0x%08X]\n", pid);
    IGuiBackend* guiBackend = &Backend::GetInstance();

    Driver::SwTimer t(35000);
    bool request = true;
    while (true) {
        if (request) {
            request = false;

            guiBackend->sendEventToBackend(G2BEvent::UserAppStart{ pid, 0 });
        }

        if (t.check()) {
            request = true;
        } else {
            OS::Delay(1000);
        }
    }
}
